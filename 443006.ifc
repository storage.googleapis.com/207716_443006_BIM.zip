Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-08-19T18:16:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 19 18:16:00 2021 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{8A29C541-54E6-4C39-9FA7-44FB5890CDC1}\ifc * Database version: 5507 * Database creation date: Thu Aug 19 18:15:59 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 19 18:16:00 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 19 18:16:00 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 443006 Handwheel, M30x1.5, 443006(2021):443006 Handwheel, M30x1.5:434766
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - NominalDepth: 49.7431 mm; NominalHeight: 38.9208 mm; NominalWidth: 38.9243 mm
Type - General - Author: BIMstone; BIMObjectName: 443006(2021); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_65_54_95_89; Uniclass2015Description: Thermostatic radiator valves; Uniclass2015Reference: Pr_65_54_95_89; Version: 1; VersionDate: 05/08/2021
Type - Green Building Properties - Customs Code: 84819000; EAN Number: 6414150098130; LVI Number: 4032048
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/443006; Catalog Drawing URL: http://static.oras.com/catdrw/443006; Dimension Drawing URL: http://static.oras.com/dimdrw/443006; FDV Document URL: http://www.oras.com/datasheet/443006/en/fdv; Group: RadiatorValve; Manufacturer: Oras; Model: 443006 Handwheel, M30x1.5; Name_en: 443006 Handwheel, M30x1.5; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package Weight: 0.057 kg; Product Code: 443006; Product Datasheet: http://www.oras.com/datasheet/443006/en; Product Family: Oras; Product Image URL: http://static.oras.com/image/443006; Product URL: http://static.oras.com/443006; Technical DataSheet URL: http://www.oras.com/datasheet/443006/en; Type Name: 443006 Handwheel, M30x1.5
Type - Materials and Finishes - ThermostatMainMaterial: Fine Textured - White
Type - Mechanical - Installation and Maintenance: http://static.oras.com/manual/443006
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 443006(2021); Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 443006; Name: 443006 Handwheel, M30x1.5; ReplacementCost: n/a; Shape: Sculptured; Size: 40x50x40 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 443006; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 443006 Handwheel, M30x1.5
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.00638857 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.0000815436 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 443006(2021): 443006 Handwheel, M30x1.5; Family and Type: 443006(2021): 443006 Handwheel, M30x1.5; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 443006(2021): 443006 Handwheel, M30x1.5; Type Id: 443006(2021): 443006 Handwheel, M30x1.5; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
